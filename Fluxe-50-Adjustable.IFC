Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Fluxe-50-Adjustable.IFC
Time: 2016-10-31T12:43:09
Written by: SwIFC
Made in: SolidWorks 2016

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Fluxe-50-Adjustable
In: Default Storey
Material: Steel
PSet_Type_Identity_Data - OmniClass Number: 23.80.70.11.14.11; OmniClass Title: Downlights
PSet_Mass_Property - Mass Measure: 61.1969; Area Measure: 11565.8 m2; Volume Measure: 61196.9 m3
